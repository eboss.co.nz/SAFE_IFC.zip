Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: 8e2f03ed-701c-444d-9d3f-1e6d2ce6ad5a, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Planimetria di default]
File name: 0001
Time: 2024-02-22T08:08:46+01:00
Written by: ODA SDAI 22.12
Made in: 23.1.30.97 - Exporter 23.2.5.0 - Alternate UI 23.2.5.0

# IfcProject, 0001
LongName: Nome del progetto; Phase: Stato del progetto

# IfcSite, Default
RefLatitude: 41, 47, 59, 997253; RefLongitude: 12, 36, 0, 1373; RefElevation: 0 cm
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data di consegna; Indirizzo del progetto: Immettere l'indirizzo; Nome del cliente: Proprietario; Nome del progetto: Nome del progetto; Numero del progetto: 0001; Stato del progetto: Stato del progetto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data di consegna; Indirizzo del progetto: Immettere l'indirizzo; Nome del cliente: Proprietario; Nome del progetto: Nome del progetto; Numero del progetto: 0001; Stato del progetto: Stato del progetto

# IfcBuildingStorey: Livello:Estremità 8 mm (2)
Quote - Altezza di calcolo: 0 cm
Dati identità - Piano edificio: yes; Strutturale: no
Altro - Categoria: Livelli; Famiglia: Livello; Famiglia e tipo: Livello: Estremità 8 mm; ID tipo: 333; Tipo: Estremità 8 mm
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Grafica(Type) - Colore: 0; Modello di linea: Centro; Simbolo: M_Estremità del livello - Triangolo; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Dati identità(Type) - Nome del tipo: Estremità 8 mm
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello
Name | LongName = Nome | Elevation (cm) = Quota altimetrica (cm)
Livello 1 | Livello 1 | 0
Livello 2 | Livello 2 | 300

# IfcBuildingElementProxy: ROTHOB_Rothoblaas_FallProtection_ParexbendA4_180DegreeAngle:72x116x565mm, ROTHOB_Rothoblaas_FallProtection_ParexbendA4_180DegreeAngle:72x116x565mm:379703
In: Livello 2
Type - ElementType: FALL_ARRESTER_DEVICES; PredefinedType: USERDEFINED; Material: ROTHOB_Rothoblaas_StainlessSteel
Type - Generale - Author: Vitor Ferronato; BIMObjectName: ROTHOB_Rothoblaas_FallProtection_ParexbendA4_180DegreeAngle; ManufacturerName: ROTHO BLAAS SRL; ManufacturerURL: www.rothoblaas.com; OmniClassCode: 23-27 71 21; OmniClassTitle: Fall Arrest Systems; OmniClassVersion: 2012-05-16; ProductInformation: https://www.rothoblaas.com/products/fall-protection-system/anchor-lines/components/patrol; Revision: n/a; UniClass2015Code: Pr_40_70_75_29; UniClass2015Title: Fall arrester devices; UniClass2015Version: Products v1.30; Version: 1
Type - Vincoli - Prospetto di default: 121.92 cm
Type - Materiali e finiture - ObjectMaterial: ROTHOB_Rothoblaas_StainlessSteel
Type - Quote - Height_H: 11.6 cm; Length_L: 56.5 cm; Width_B: 7.2 cm
Type - Dati identità - Nome del tipo: 72x116x565mm; Numero OmniClass: 23.27.71.21; Titolo OmniClass: Fall Arrest Systems
Type - Altro - Categoria: Collegamenti strutturali; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_40_70_75_29 - Fall arrester devices; CodePerformance: Safety system; Color: Silver; Constituents: n/a; Description: External pass-through angle bracket for A4 façades adjustable 105°-165°; DurationUnit: Years; ExpectedLife: n/a; Features: Wall-mounted lifeline; Finish: n/a; Grade: n/a; Manufacturer: info@rothoblaas.com; Material: AISI 316 stainless steel grade 1.4401; MinWeight: 0.7 kg; ModelDisclaimer: The latest version of the data sheets can be found on our website; ModelNumber: PAREXBENDA4; ModelReference: n/a; Name: Lifeline angle element; Nome famiglia: ROTHOB_Rothoblaas_FallProtection_ParexbendA4_180DegreeAngle; NominalHeight: 11.6 cm; NominalLength: 56.5 cm; NominalWidth: 7.2 cm; ReferenceStandard: EN 795:2012 C; ReplacementCost: n/a; Shape: Three-dimensional; Size: 72x116x565 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: n/a; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Silver
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: info@rothoblaas.com
Type - Pset_ProductRequirements - Name: Lifeline angle element; Category: Pr_40_70_75_29 - Fall arrester devices
Type - Pset_ProvisionForVoid - Shape: Three-dimensional
Pset_BuildingElementProxyCommon - Reference: 72x116x565mm; sets with these values: 2
Vincoli - Host: <non associato>; Livello: Livello 2; Livello abaco: Livello 2; Quota altimetrica da livello: -300 cm
Fasi - Fase di creazione: Nuova costruzione
Quote - Volume: 0.0000840463 m3
Altro - Famiglia: ROTHOB_Rothoblaas_FallProtection_ParexbendA4_180DegreeAngle; Famiglia e tipo: ROTHOB_Rothoblaas_FallProtection_ParexbendA4_180DegreeAngle: 72x116x565mm; ID tipo: 381124; Tipo: 72x116x565mm
