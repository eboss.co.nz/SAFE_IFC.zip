Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.0]
File name: Project Number
Time: 2021-03-29T09:20:26
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190510_1515(x64) - Exporter 18.3.3.18 - Alternate UI 18.3.3.18
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Mar 29 09:20:26 2021 * Host: DESKTOP-UMACVF4 * Database: C:\Users\2DTO6D\AppData\Local\Temp\{E6E1646C-9530-4035-B36F-6A03E4D7DEC1}\ifc * Database version: 5507 * Database creation date: Mon Mar 29 09:20:25 2021 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Mon Mar 29 09:20:26 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Mar 29 09:20:26 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: Slide3, Slide3:Slide3:232500
In: Level 1
Type - Material: Acciaio INOX - AISI304 | lega EN AW-6082
Type - Constraints - Default Elevation: 1219.2 mm
Type - Identity Data - Catalogue: Fall protection and safety; Catalogue Section: Anchor Lines; Family Version: 1.0.0; Manufacturer: Rotho Blaas srl; Model: SLIDE3; Product Type: SLIDE3; Type Name: Slide3; URL: https://www.rothoblaas.it/prodotti/sistemi-anticaduta/linee-vita/pass-through-air/slide-3
Type - Materials and Finishes - Material_RothoBlaas: Acciaio INOX - AISI304 | lega EN AW-6082
Type - Other - Category: Specialty Equipment; Family Name: Slide3
Pset_BuildingElementProxyCommon - Reference: Slide3; IsExternal: no
Pset_ManufacturerTypeInformation - Manufacturer: Rotho Blaas srl
Constraints - Level: Level: Level 1; Offset: 60 mm; Work Plane: Floor : Generic Floor - 100mm
Dimensions - Area: 0.0306193 m2; Volume: 0.000296106 m3
Other - Family: Slide3: Slide3; Family and Type: Slide3: Slide3; Schedule Level: Level: Level 1; Type: Slide3: Slide3; Type Id: Slide3: Slide3
Phasing - Phase Created: New Construction
