Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: 7254510d-1f7a-4263-8e67-bef965758bcc, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Planimetria di default], ExchangeRequirement [Structural]
File name: 0001
Time: 2024-03-21T09:44:32+01:00
Written by: ODA SDAI 22.12
Made in: 23.1.30.97 - Exporter 23.2.5.0 - Alternate UI 23.2.5.0

# IfcProject, 0001
LongName: Nome del progetto; Phase: Stato del progetto

# IfcSite, Default
RefLatitude: 41, 47, 59, 997253; RefLongitude: 12, 36, 0, 1373; RefElevation: 0 cm
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data di consegna; Indirizzo del progetto: Immettere l'indirizzo; Nome del cliente: Proprietario; Nome del progetto: Nome del progetto; Numero del progetto: 0001; Stato del progetto: Stato del progetto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data di consegna; Indirizzo del progetto: Immettere l'indirizzo; Nome del cliente: Proprietario; Nome del progetto: Nome del progetto; Numero del progetto: 0001; Stato del progetto: Stato del progetto

# IfcBuildingStorey: Livello:Estremità 8 mm (2)
Quote - Altezza di calcolo: 0 cm
Dati identità - Piano edificio: yes; Strutturale: no
Altro - Categoria: Livelli; Famiglia: Livello; Famiglia e tipo: Livello: Estremità 8 mm; ID tipo: 333; Tipo: Estremità 8 mm
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Grafica(Type) - Colore: 0; Modello di linea: Centro; Simbolo: M_Estremità del livello - Triangolo; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Dati identità(Type) - Nome del tipo: Estremità 8 mm
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello
Name | LongName = Nome | Elevation (cm) = Quota altimetrica (cm)
Livello 1 | Livello 1 | 0
Livello 2 | Livello 2 | 300

# IfcBuildingElementProxy: ROTHOB_Rothoblaas_FallProtection_Angsup:275x16mm, ROTHOB_Rothoblaas_FallProtection_Angsup:275x16mm:380571
In: Livello 2
Type - ElementType: FALL_ARRESTER_DEVICES; PredefinedType: USERDEFINED; Material: ROTHOB_Rothoblaas_StainlessSteel
Type - Generale - Author: Vitor Ferronato; BIMObjectName: ROTHOB_Rothoblaas_FallProtection_Angsup; ManufacturerName: ROTHO BLAAS SRL; ManufacturerURL: www.rothoblaas.com; OmniClassCode: 23-27 71 21; OmniClassTitle: Fall Arrest Systems; OmniClassVersion: 2012-05-16; ProductInformation: https://www.rothoblaas.com/products/fall-protection-system/anchor-lines/components/patrol; Revision: n/a; UniClass2015Code: Pr_40_70_75_29; UniClass2015Title: Fall arrester devices; UniClass2015Version: Products v1.33; Version: 1
Type - Vincoli - Prospetto di default: 121.92 cm
Type - Materiali e finiture - ObjectMaterial: ROTHOB_Rothoblaas_StainlessSteel
Type - Quote - Height_H: 1.6 cm; Length_L: Range 0-550; Width_B: 27.5 cm
Type - Dati identità - Nome del tipo: 275x16mm; Numero OmniClass: 23.27.71.21; Titolo OmniClass: Fall Arrest Systems
Type - Altro - Categoria: Collegamenti strutturali; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_40_70_75_29 - Fall arrester devices; CodePerformance: Safety system; Color: Silver; Constituents: Plate, fasteners (bolts, nuts); Description: Support for PASANGBEND, OHANGINT and OHANGEXT; DurationUnit: Years; ExpectedLife: n/a; Features: Horizontal lifeline and overhead; Finish: n/a; Grade: n/a; Manufacturer: info@rothoblaas.com; Material: AISI 304 stainless steel grade 1.4031; MinWeight: 0.826 kg; ModelDisclaimer: The latest version of the data sheets can be found on our website; ModelNumber: ANGSUP; ModelReference: n/a; Name: Lifeline angle bracket; Nome famiglia: ROTHOB_Rothoblaas_FallProtection_Angsup; NominalHeight: 1.6 cm; NominalLength: n/a; NominalWidth: 27.5 cm; ReferenceStandard: EN 795:2012 C; ReplacementCost: n/a; Shape: Three-dimensional; Size: 275x16 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: n/a; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Silver
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: info@rothoblaas.com
Type - Pset_ProductRequirements - Name: Lifeline angle bracket; Category: Pr_40_70_75_29 - Fall arrester devices
Type - Pset_ProvisionForVoid - Shape: Three-dimensional
Pset_BuildingElementProxyCommon - Reference: 275x16mm; sets with these values: 2
Vincoli - Host: <non associato>; Livello: Livello 2; Livello abaco: Livello 2; Quota altimetrica da livello: -300 cm
Fasi - Fase di creazione: Nuova costruzione
Quote - RotationAngle: 115 deg; Volume: 0.000208488 m3
Altro - Famiglia: ROTHOB_Rothoblaas_FallProtection_Angsup; Famiglia e tipo: ROTHOB_Rothoblaas_FallProtection_Angsup: 275x16mm; ID tipo: 380539; Tipo: 275x16mm
