Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: fe87f059-d7da-4b4a-809b-b1b12a5de2b0, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Planimetria di default], ExchangeRequirement [Structural]
File name: 0001
Time: 2023-11-16T08:48:46+01:00
Written by: ODA SDAI 22.12
Made in: 23.1.10.4 - Exporter 23.2.5.0 - Alternate UI 23.2.5.0

# IfcProject, 0001
LongName: Nome del progetto; Phase: Stato del progetto

# IfcSite, Default
RefLatitude: 41, 47, 59, 997253; RefLongitude: 12, 36, 0, 1373; RefElevation: 0 cm
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data di consegna; Indirizzo del progetto: Immettere l'indirizzo; Nome del cliente: Proprietario; Nome del progetto: Nome del progetto; Numero del progetto: 0001; Stato del progetto: Stato del progetto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data di consegna; Indirizzo del progetto: Immettere l'indirizzo; Nome del cliente: Proprietario; Nome del progetto: Nome del progetto; Numero del progetto: 0001; Stato del progetto: Stato del progetto

# IfcBuildingStorey: Livello:Estremità 8 mm (2)
Quote - Altezza di calcolo: 0 cm
Dati identità - Piano edificio: yes; Strutturale: no
Altro - Categoria: Livelli; Famiglia: Livello; Famiglia e tipo: Livello: Estremità 8 mm; ID tipo: 333; Tipo: Estremità 8 mm
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Grafica(Type) - Colore: 0; Modello di linea: Centro; Simbolo: M_Estremità del livello - Triangolo; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Dati identità(Type) - Nome del tipo: Estremità 8 mm
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello
Name | LongName = Nome | Elevation (cm) = Quota altimetrica (cm)
Livello 1 | Livello 1 | 0
Livello 2 | Livello 2 | 300

# IfcBuildingElementProxy: ROTHOB_Rothoblaas_FallProtection_Tower:150x500x150mm, ROTHOB_Rothoblaas_FallProtection_Tower:150x500x150mm:379745
In: Livello 2
Type - Material: ROTHOB_Rothoblaas_Steel_ZincPlated
Type - Generale - Author: ROTHO BLAAS SRL; BIMObjectName: ROTHOB_Rothoblaas_FallProtection_Tower; ManufacturerName: ROTHO BLAAS SRL; ManufacturerURL: www.rothoblaas.com; OmniClassCode: 23-27 71 21; OmniClassTitle: Fall Arrest Systems; OmniClassVersion: 2012-05-16; ProductInformation: https://www.rothoblaas.com/products/fall-protection-system/anchor-lines/components/tower; Revision: n/a; UniClass2015Code: Pr_40_70_75_75; UniClass2015Title: Safety access anchor devices; UniClass2015Version: Products v1.30; Version: 2
Type - Vincoli - ModelNumberCode: 500; Prospetto di default: 121.92 cm
Type - Materiali e finiture - ObjectMaterial: ROTHOB_Rothoblaas_Steel_ZincPlated
Type - Quote - CylinderDiameter_d1: 4.8 cm; Height_H: 50 cm; Length_L: 15 cm; Width_B: 15 cm
Type - Dati identità - Nome del tipo: 150x500x150mm; Numero OmniClass: 23.27.71.21; Titolo OmniClass: Fall Arrest Systems
Type - Altro - Categoria: Collegamenti strutturali; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_40_70_75_75 - Safety access anchor devices; CodePerformance: Safety system; Color: Grey; Constituents: n/a; Description: Support for fall protection systems for timber, concrete and steel roofs; DurationUnit: Years; ExpectedLife: n/a; Features: Horizontal lifeline and anchor points; Finish: Zinc plated; Grade: n/a; Manufacturer: info@rothoblaas.com; Material: S235JR zinc plated steel; MinWeight: 3.644 kg; ModelDisclaimer: The latest version of the data sheets can be found on our website; ModelNumber: TOWER500; ModelReference: n/a; Name: Support for fall protection systems; Nome famiglia: ROTHOB_Rothoblaas_FallProtection_Tower; NominalHeight: 50 cm; NominalLength: 15 cm; NominalWidth: 15 cm; ReferenceStandard: EN 795:2012 A+C; ReplacementCost: n/a; Shape: Three-dimensional; Size: 150x500x150 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: n/a; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Grey
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: info@rothoblaas.com
Type - Pset_ProductRequirements - Name: Support for fall protection systems; Category: Pr_40_70_75_75 - Safety access anchor devices
Type - Pset_ProvisionForVoid - Shape: Three-dimensional
Pset_BuildingElementProxyCommon - Reference: 150x500x150mm; sets with these values: 2
Vincoli - Host: <non associato>; Livello: Livello 2; Livello abaco: Livello 2; Quota altimetrica da livello: 0 cm
Fasi - Fase di creazione: Nuova costruzione
Quote - Volume: 0.000260857 m3
Altro - Famiglia: ROTHOB_Rothoblaas_FallProtection_Tower; Famiglia e tipo: ROTHOB_Rothoblaas_FallProtection_Tower: 150x500x150mm; ID tipo: 379702; Tipo: 150x500x150mm
