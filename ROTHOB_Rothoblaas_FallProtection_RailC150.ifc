Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: 1f757935-6625-49ca-bff3-034dcbb1bd85, VersionGUID: 7fef66b2-c47b-4580-a67e-0c9b7624a0a5, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Coordinate condivise, ProjectSite: Planimetria di default], ExchangeRequirement [Structural]
File name: ROTHOB_Rothoblaas_FallProtection_RailC150.ifc
Time: 2024-10-01T15:08:15+01:00
Written by: ODA SDAI 24.6
Made in: Autodesk Revit 24.2.20.41 (ITA) - IFC 24.2.20.41

# IfcProject, 0001
LongName: Nome del progetto; Phase: Stato del progetto

# IfcSite, Default
RefLatitude: 41, 47, 59, 997253; RefLongitude: 12, 36, 0, 1373; RefElevation: 0 cm
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data di consegna; Indirizzo del progetto: Immettere l'indirizzo; Nome del cliente: Proprietario; Nome del progetto: Nome del progetto; Numero del progetto: 0001; Stato del progetto: Stato del progetto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data di consegna; Indirizzo del progetto: Immettere l'indirizzo; Nome del cliente: Proprietario; Nome del progetto: Nome del progetto; Numero del progetto: 0001; Stato del progetto: Stato del progetto

# IfcBuildingStorey: Livello:Estremità 8 mm (2)
Altro - Categoria: Livelli; Famiglia: Livello; Famiglia e tipo: Livello: Estremità 8 mm; ID tipo: 333; Tipo: Estremità 8 mm
Quote - Altezza di calcolo: 0 cm
Dati identità - Piano edificio: yes; Strutturale: no
Altro(Tipo) - Categoria: Livelli; Nome famiglia: Livello
Vincoli(Tipo) - Base quota altimetrica: Punto base progetto
Grafica(Tipo) - Colore: 0; Modello di linea: Centro; Simbolo: M_Estremità del livello - Triangolo; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Dati identità(Tipo) - Nome del tipo: Estremità 8 mm
Name | LongName = Nome | Elevation (cm) = Quota altimetrica (cm)
Livello 1 | Livello 1 | 0
Livello 2 | Livello 2 | 300

# IfcBuildingElementProxy: ROTHOB_Rothoblaas_FallProtection_RailC150:RAILC150_180x41x511mm, ROTHOB_Rothoblaas_FallProtection_RailC150:RAILC150_180x41x511mm:382232
In: Livello 2
Type - ElementType: FALL_ARRESTER_DEVICES; PredefinedType: USERDEFINED; Material: ROTHOB_Rothoblaas_Aluminium_Hardened
Type - Altro - Categoria: Collegamenti strutturali; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_40_70_75_29 - Fall arrester devices; CodePerformance: Safety system; Color: Silver; Constituents: n/a; Description: Aluminium 150° bend for rail; DurationUnit: Years; ExpectedLife: n/a; Features: Horizontal lifeline; Finish: n/a; Grade: n/a; Manufacturer: info@rothoblaas.com; Material: EN AW 6063 T6; MinWeight: 1.269 kg; ModelDisclaimer: The latest version of the data sheets can be found on our website; ModelNumber: RAILC150; ModelReference: n/a; Name: Rail; Nome famiglia: ROTHOB_Rothoblaas_FallProtection_RailC150; NominalHeight: 4.1 cm; NominalLength: 51.1 cm; NominalWidth: 18 cm; ReferenceStandard: EN 795:2012 D; ReplacementCost: n/a; Shape: Three-dimensional; Size: 180x41x511 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: n/a; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Vincoli - Prospetto di default: 0.131234 cm
Type - Quote - Height_H: 4.1 cm; Length_L: 51.1 cm; Width_B: 18 cm
Type - Generale - Author: Vitor Ferronato; BIMObjectName: ROTHOB_Rothoblaas_FallProtection_RailC150; ManufacturerName: ROTHO BLAAS SRL; ManufacturerURL: www.rothoblaas.com; OmniClassCode: 23-27 71 21; OmniClassTitle: Fall Arrest Systems; OmniClassVersion: 2012-05-16; ProductInformation: https://www.rothoblaas.com/products/fall-protection-system/anchor-lines/h-rail-on-floor; Revision: n/a; UniClass2015Code: Pr_40_70_75_29; UniClass2015Title: Fall arrester devices; UniClass2015Version: Products v1.33; Version: 1
Type - Dati identità - Nome del tipo: RAILC150_180x41x511mm; Numero OmniClass: 23.27.71.21
Type - Materiali e finiture - ObjectMaterial: ROTHOB_Rothoblaas_Aluminium_Hardened
Type - Pset_ElementShading - Color: Silver
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: info@rothoblaas.com
Type - Pset_ProductRequirements - Name: Rail; Category: Pr_40_70_75_29 - Fall arrester devices
Type - Pset_ProvisionForVoid - Shape: Three-dimensional
Pset_BuildingElementProxyCommon - Reference: RAILC150_180x41x511mm; sets with these values: 2
Altro - Famiglia: ROTHOB_Rothoblaas_FallProtection_RailC150; Famiglia e tipo: ROTHOB_Rothoblaas_FallProtection_RailC150: RAILC150_180x41x511mm; ID tipo: 388947; Tipo: RAILC150_180x41x511mm
Vincoli - Host: <non associato>; Livello: Livello 2; Livello abaco: Livello 2; Quota altimetrica da livello: -300 cm
Quote - Volume: 0.00046772 m3
Fasi - Fase di creazione: Nuova costruzione
