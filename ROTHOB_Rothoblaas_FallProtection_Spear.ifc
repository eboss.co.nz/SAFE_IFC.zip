Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: 8174e342-527d-423a-a500-6f65e8678a59, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Planimetria di default], ExchangeRequirement [Structural]
File name: 0001
Time: 2023-12-07T11:03:44+01:00
Written by: ODA SDAI 22.12
Made in: 23.1.10.4 - Exporter 23.2.5.0 - Alternate UI 23.2.5.0

# IfcProject, 0001
LongName: Nome del progetto; Phase: Stato del progetto

# IfcSite, Default
RefLatitude: 41, 47, 59, 997253; RefLongitude: 12, 36, 0, 1373; RefElevation: 0 mm
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data di consegna; Indirizzo del progetto: Immettere l'indirizzo; Nome del cliente: Proprietario; Nome del progetto: Nome del progetto; Numero del progetto: 0001; Stato del progetto: Stato del progetto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data di consegna; Indirizzo del progetto: Immettere l'indirizzo; Nome del cliente: Proprietario; Nome del progetto: Nome del progetto; Numero del progetto: 0001; Stato del progetto: Stato del progetto

# IfcBuildingStorey: Livello:Estremità 8 mm (2)
Quote - Altezza di calcolo: 0 mm
Dati identità - Piano edificio: yes; Strutturale: no
Altro - Categoria: Livelli; Famiglia: Livello; Famiglia e tipo: Livello: Estremità 8 mm; ID tipo: 333; Tipo: Estremità 8 mm
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Grafica(Type) - Colore: 0; Modello di linea: Centro; Simbolo: M_Estremità del livello - Triangolo; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Dati identità(Type) - Nome del tipo: Estremità 8 mm
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello
Name | LongName = Nome | Elevation (mm) = Quota altimetrica (mm)
Livello 1 | Livello 1 | 0
Livello 2 | Livello 2 | 3000

# IfcBuildingElementProxy: ROTHOB_Rothoblaas_FallProtection_Spear:50x63x380mm, ROTHOB_Rothoblaas_FallProtection_Spear:50x63x380mm:387858
In: Livello 1
Type - PredefinedType: USERDEFINED; Material: ROTHOB_Rothoblaas_StainlessSteel, ROTHOB_Rothoblaas_Aluminium
Type - Generale - Author: Vitor Ferronato; BIMObjectName: ROTHOB_Rothoblaas_FallProtection_Spear; ManufacturerName: ROTHO BLAAS SRL; ManufacturerURL: www.rothoblaas.com; OmniClassCode: 23-27 71 21; OmniClassTitle: Fall Arrest Systems; OmniClassVersion: 2012-05-16; ProductInformation: https://www.rothoblaas.com/products/fall-protection-system/anchor-lines/components/patrol; Revision: n/a; UniClass2015Code: Pr_40_70_75_75; UniClass2015Title: Safety access anchor devices; UniClass2015Version: Products v1.30; Version: 2
Type - Vincoli - Prospetto di default: 1219.2 mm
Type - Materiali e finiture - ObjectMaterial_Clamp: ROTHOB_Rothoblaas_Aluminium; ObjectMaterial_Fork: ROTHOB_Rothoblaas_StainlessSteel
Type - Quote - Height_H: 63 mm; Length_L: 380 mm; Width_B: 50 mm
Type - Dati identità - Nome del tipo: 50x63x380mm; Numero OmniClass: 23.27.71.21; Titolo OmniClass: Fall Arrest Systems
Type - Altro - Categoria: Collegamenti strutturali; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_40_70_75_75 - Safety access anchor devices; CodePerformance: Safety system; Color: Silver/Grey; Constituents: Clamp, fasteners (nuts, washers, bolts, tube); Description: Set of pair of tensioners with absorber; DurationUnit: Years; ExpectedLife: n/a; Features: Horizontal lifeline; Finish: n/a; Grade: n/a; Manufacturer: info@rothoblaas.com; Material: AISI 304 stainless steel grade 1.4301/EN AW 6082 aluminium; MinWeight: 2.193 kg; ModelDisclaimer: The latest version of the data sheets can be found on our website; ModelNumber: SPEAR; ModelReference: n/a; Name: Lifeline absorber and tensioner; Nome famiglia: ROTHOB_Rothoblaas_FallProtection_Spear; NominalHeight: 63 mm; NominalLength: 380 mm; NominalWidth: 50 mm; ReferenceStandard: EN 795:2012 C; ReplacementCost: n/a; Shape: Three-dimensional; Size: 50x63x380 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: n/a; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Silver/Grey
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: info@rothoblaas.com
Type - Pset_ProductRequirements - Name: Lifeline absorber and tensioner; Category: Pr_40_70_75_75 - Safety access anchor devices
Type - Pset_ProvisionForVoid - Shape: Three-dimensional
Pset_BuildingElementProxyCommon - Reference: 50x63x380mm; sets with these values: 2
Vincoli - Host: <non associato>; Livello: Livello 1; Livello abaco: Livello 1; Quota altimetrica da livello: 0 mm
Fasi - Fase di creazione: Nuova costruzione
Quote - Volume: 0.000185683 m3
Altro - Famiglia: ROTHOB_Rothoblaas_FallProtection_Spear; Famiglia e tipo: ROTHOB_Rothoblaas_FallProtection_Spear: 50x63x380mm; ID tipo: 387768; Tipo: 50x63x380mm
