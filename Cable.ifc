Properties of the parts of a building model (IFC2X3)

# File
Description: IFC 2x3 Building Model
Time: 2021-06-03T16:11:09
Made in: ASIFC - 3.1.0.1142

# IfcSite
RefElevation: 0 mm

# IfcProxy (3)
ProxyType: PRODUCT
